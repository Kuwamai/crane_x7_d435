Commit message: Edit

File: urdf/d435.urdf.xacro (robot description, xacro)
@@ -35,6 +35,5 @@
       <child  link="camera_link"/>
     </joint>
-    <link name="camera_link">
-    </link>
+    <link name="camera_link"/>
   </xacro:macro>
 </robot>
